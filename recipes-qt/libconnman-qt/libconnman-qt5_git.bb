DEPENDS = "qtbase qtdeclarative"

inherit qmake5

require libconnman-qt.inc
